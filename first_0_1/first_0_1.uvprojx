# Keil uVision project first_0_1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: first_0_1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\User\bsp;.\User\driver;.\User\algorithm;.\User\app;.\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group BSP
    ./User/bsp/: bsp_board.c bsp_board.h bsp_systick.c bsp_systick.h bsp_led.c bsp_led.h bsp_usart.c bsp_usart.h bsp_iic.c bsp_iic.h bsp_mpu6050.c bsp_mpu6050.h bsp_ultrasonic.c bsp_ultrasonic.h bsp_adc.c bsp_adc.h bsp_debug.c bsp_debug.h
    ./User/bsp/test/: bsp_mpu_motor_test.c bsp_mpu_motor_test.h
    ./User/bsp/oled/: bsp_oled.c bsp_oled.h
  group Driver
    ./User/driver/: drv_tb6612.c drv_tb6612.h
    ./: tast_dianji.c tast_dianji.h
  group Algorithm
    ./User/algorithm/: algo_filter.c algo_filter.h algo_pid.c algo_pid.h
  group App
    ./User/app/: app_protocol.c app_protocol.h app_state_machine.c app_state_machine.h app_control.c app_control.h app_navigation.c app_navigation.h app_task.c app_task.h app_oled.c app_oled.h
